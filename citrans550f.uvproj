# Keil uVision project citrans550f.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: citrans550f +hex
  c flags: Optimize=8 SizeSpeed=1
  asm include: ..\单盘软件
  group Source Group 1
    ./: GF2488-01F1-E1-RST.C NewLib9.LIB
